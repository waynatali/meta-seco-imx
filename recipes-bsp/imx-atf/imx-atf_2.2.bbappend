SRCBRANCH = "github.com/master"
SRC_URI = "git://source.codeaurora.org/external/imx/imx-atf.git;protocol=https;branch=${SRCBRANCH}"
SRCREV = "66306814586b1bf6bcb859aaad218ec3bb090e94"
